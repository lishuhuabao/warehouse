# Keil uVision project BootLoader.uvprojx, settings and files
target BootLoader (6190000::V6.19::ARMCLANG)
  device: STM32F072CBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: BootLoader +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F072xB,USE_HAL_LEGACY
  c include: ../Drivers/STM32F0xx_HAL_Driver/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../Drivers/CMSIS/Include;..\Bsp;..\Comm;..\Handler;..\User;..\radio\inc;..\Task;..\Wifi
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000100 size 0x3e00
  group Application/MDK-ARM
    ./: startup_stm32f072xb.s
  group User
    ../User/: main.c stm32f0xx_hal_msp.c stm32f0xx_it.c usrOs.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_usart.c stm32f0xx_hal_usart_ex.c stm32f0xx_hal_dma.c
  group Drivers/CMSIS
    ../User/: system_stm32f0xx.c
  group Bsp
    ../Bsp/: Bsp.c BspDataRecord.c BspDebug.c BspIntFlash.c BspLed.c BspPc.c BspSimPwm.c BspUart.c BspWifi.c
  group Comm
    ../Comm/: CommIap.c CommPcServer.c
  group Wifi
    ../Wifi/: Esp12F.c
