# Keil uVision project Net.uvprojx, settings and files
target Net (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F072CBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: Net +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_HAL_DRIVER,STM32F072xB,USE_HAL_LEGACY
  c include: ../Drivers/STM32F0xx_HAL_Driver/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../Drivers/CMSIS/Include;..\Bsp;..\Comm;..\Handler;..\User;..\radio\inc;..\Task;..\Wifi
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x20000
  memory RVCT9: RAM 0x20000100 size 0x3e00
  group Application/MDK-ARM
    ./: startup_stm32f072xb.s
  group User
    ../User/: usrOs.c main.c stm32f0xx_hal_msp.c stm32f0xx_it.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_exti.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c
  group Drivers/CMSIS
    ../User/: system_stm32f0xx.c
  group Bsp
    ../Bsp/: Bsp.c BspDataRecord.c BspDebug.c BspIntFlash.c BspLed.c BspLora.c BspPc.c BspPort.c BspSimPwm.c BspSimUart.c BspUart.c BspWifi.c
  group Comm
    ../Comm/: CommLora.c CommLoraPro.c CommPcServer.c DecodeDataFromPcSer.c
  group Handler
    ../Handler/: HandlerProcess.c
  group Radio
    ../radio/src/: sx1276.c sx1276_hal.c sx1276_timer.c sx1276_user.c sx1276-board.c
  group Task
    ../Task/: stask.c stick.c stimer.c
  group Wifi
    ../Wifi/: Esp12F.c
software components: CMSIS:CORE 5.6.0
