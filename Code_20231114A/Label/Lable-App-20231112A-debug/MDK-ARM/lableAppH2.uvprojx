# Keil uVision project lableAppH2.uvprojx, settings and files
target LableAppH2V2 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32L151CBTxA STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.3.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LableAppH2 +hex
  AfterMake: fromelf.exe --bin -o  ./Output/@L.bin  ./Output/@L.axf
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_HAL_DRIVER,STM32L151xBA,USE_HAL_DRIVER,STM32L151xBA
  c include: ../Drivers/STM32L1xx_HAL_Driver/Inc;../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L1xx/Include;../Drivers/CMSIS/Include;..\Bsp;..\User;..\Comm;..\Handler;..\QrCode;..\Task;..\radio\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32l151xba.s
  group Application/User
    ../User/: main.c stm32l1xx_hal_msp.c stm32l1xx_it.c usrOs.c
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_i2c.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_dma.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_spi.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c
  group Drivers/CMSIS
    ../User/: system_stm32l1xx.c
  group Bsp
    ../Bsp/: Bsp.c BspDataRecord.c BspIntFlash.c BspLed.c BspLora.c BspPort.c BspSimPwm.c BspLcdWf29Font.c BspLcdWf29.c BspKey.c BspGt21L16S2W.c BspBuz.c BspIdwg.c BspRtc.c BspDebug.c
  group Comm
    ../Comm/: CommLora.c CommLoraPro.c CommIap.c
  group Handler
    ../Handler/: HandlerKey.c HandlerPowerManeg.c
  group Task
    ../Task/: stask.c stimer.c
  group Radio
    ../radio/src/: sx1276.c sx1276_hal.c sx1276_timer.c sx1276_user.c sx1276-board.c
software components: CMSIS:CORE 5.3.0
