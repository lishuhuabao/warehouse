# Keil uVision project BootLoader.uvprojx, settings and files
target BootLoader (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32L151CBxxA STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: BootLoader +hex
  AfterMake: fromelf.exe --bin -o  ./Output/@L.bin  ./Output/@L.axf
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_HAL_DRIVER,STM32L151xBA,USE_HAL_DRIVER,STM32L151xBA
  c include: ../Drivers/STM32L1xx_HAL_Driver/Inc;../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L1xx/Include;../Drivers/CMSIS/Include;..\Bsp;..\User;..\Comm;..\Handler;..\QrCode;..\Task;..\radio\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32l151xba.s
  group Application/User
    ../User/: main.c stm32l1xx_hal_msp.c stm32l1xx_it.c usrOs.c
    ./: changelog.txt
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal.c stm32l1xx_hal_rcc.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_dma.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_spi.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rcc_ex.c
  group Drivers/CMSIS
    ../User/: system_stm32l1xx.c
  group Bsp
    ../Bsp/: Bsp.c BspDataRecord.c BspIntFlash.c BspLora.c BspRtc.c
  group Comm
    ../Comm/: CommIap.c CommLora.c CommLoraPro.c
  group Handler
    ../Handler/: HandlerPowerManeg.c
  group Task
    ../Task/: stask.c stimer.c
  group radio
    ../radio/src/: sx1276.c sx1276_hal.c sx1276_timer.c sx1276_user.c sx1276-board.c
software components: CMSIS:CORE 5.6.0
